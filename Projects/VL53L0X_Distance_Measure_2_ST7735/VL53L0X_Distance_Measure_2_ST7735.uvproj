# Keil uVision project VL53L0X_Distance_Measure_2_ST7735.uvproj, settings and files
target VL53L0X_Distance_Measure_1_ST7735 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: VL53L0X_Distance_Measure_1_ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../../inc;../../VL53L0X;../../VL53L0X_I2C/;../../core/inc;../../platform/inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Files
    ../../inc/: LED.c PLL.c startup.s ST7735.c I2C.c
    ../../VL53L0X_I2C/: VL53L0X_I2C.c
    ../../VL53L0X/: VL53L0X.c
    ../../core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../platform/src/: vl53l0x_platform.c
    ./: VL53L0X_Distance_Measure_1_ST7735.c
