# Keil uVision project VL53L0X_Distance_Measure_3_ST7735.uvproj, settings and files
target VL53L0X_Distance_Measure_3_ST7735 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: VL53L0X_Distance_Measure_3_ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../../lib/_tm4c, ../../lib/common/inc, ../../lib/LCD/ST7735/inc, ../../lib/LiDAR/VL53L0X/core/inc, ../../lib/LiDAR/VL53L0X/platform/inc, ../../lib/LiDAR/VL53L0X/VL53L0X/inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
    ../../lib/common/src/: I2C.c PLL.c
    ../../lib/LiDAR/VL53L0X/VL53L0X/src/: VL53L0X.c VL53L0X_I2C.c xshut.c
    ../../lib/LiDAR/VL53L0X/ST7735/src/: ST7735.c
    ../../lib/LiDAR/VL53L0X/platform/src/: vl53l0x_platform.c
    ../../lib/LiDAR/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../lib/_tm4c/: startup.s
